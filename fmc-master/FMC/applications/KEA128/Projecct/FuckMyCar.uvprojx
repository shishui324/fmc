# Keil uVision project FuckMyCar.uvprojx, settings and files
target FMC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FuckMyCar
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\USER\inc;..\..\..\software\Car;..\..\..\software\Debug;..\..\..\software\Libraries\startup\DeviceSupport;..\..\..\software\Libraries\startup\CoreSupport;..\..\..\software\Libraries\drives\inc;..\..\..\software\Module
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group drives
    ../../../software/Libraries/drives/src/: common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_spi.c KEA128_systick.c KEA128_uart.c misc.c
  group startup
    ../../../software/Libraries/startup/DeviceSupport/: system_SKEAZ1284.c
    ../../../software/Libraries/startup/DeviceSupport/MDK-ARM/: startup_SKEAZ1284.s
  group module
    ../../../software/Module/: OLED.c Myflash.c
  group car
    ../../../software/Car/: motor.c sensor.c struct.h Car_Key.c control.c encode.c BB.c
  group debug
    ../../../software/Debug/: ANO_DT.c UI.c MYUI.c
    ../../../software/Car/: Debug.c
  group user
    ../USER/src/: isr.c main.c
  group other
    ../../../software/Other/: mark.txt
